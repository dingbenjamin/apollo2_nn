# Keil uVision project fann_apollo2.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IRAM(0x10000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fann_apollo2
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4 __FPU_PRESENT=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group Source Group 1
    ./: main.c performance.c
    ./fann/: fann.c
    ./extraction/: extraction.c loop.c
    ./sensors/: s_globals.h
software components: CMSIS:DSP 1.5.2
